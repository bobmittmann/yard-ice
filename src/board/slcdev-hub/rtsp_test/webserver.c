/* 
 * Copyright(C) 2012 Robinson Mittmann. All Rights Reserved.
 * 
 * This file is part of the YARD-ICE.
 *
 * This library is free software; you can redistribute it and/or
 * modify it under the terms of the GNU Lesser General Public
 * License as published by the Free Software Foundation; either
 * version 3.0 of the License, or (at your option) any later version.
 * 
 * This library is distributed in the hope that it will be useful,
 * but WITHOUT ANY WARRANTY; without even the implied warranty of
 * MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the GNU
 * Lesser General Public License for more details.
 * 
 * You can receive a copy of the GNU Lesser General Public License from 
 * http://www.gnu.org/
 */

/** 
 * @file webserver.c
 * @brief YARD-ICE application main
 * @author Robinson Mittmann <bobmittmann@gmail.com>
 */ 

#include <stdio.h>
#include <string.h>
#include <stdlib.h>
#include <stdbool.h>
#include <tcpip/httpd.h>
#include <thinkos.h>
#include <trace.h>
#include <fixpt.h>

#include "rtsp.h"
#include "audio.h"

extern struct rtsp_client rtsp;

/*---------------------------------------------------------------------------
  Common HTML macros
  ---------------------------------------------------------------------------*/

#define HTML_FOOTER "<hr>\r\n"\
	"<a href=\"https://code.google.com/p/yard-ice\">"\
	"<img src=\"thinkos47x20.png\"></a>\r\n"\
	" - Cortex-M Operating System - \r\n"\
	"<i><a href=\"https://code.google.com/p/yard-ice\">YARD-ICE</a></i><br>\r\n"\
	"&copy; Copyright 2013-2015, Bob Mittmann<br>\r\n"\
	"</body>\r\n</html>\r\n"

#define DOCTYPE_HTML "<!DOCTYPE html PUBLIC " \
	"\"-//W3C//DTD XHTML 1.0 Strict//EN\" "\
	"\"http://www.w3.org/TR/xhtml1/DTD/xhtml1-strict.dtd\">\r\n"\
	"<html xmlns=\"http://www.w3.org/1999/xhtml\">\r\n"

#define SERVER "Server: " HTTPD_SERVER_NAME "\r\n"

#define META_COPY "<meta name=\"copyright\" "\
	"content=\"Copyright (c) Bob Mittmann 2014-2015\"/>\r\n"

#define META_HTTP "<meta http-equiv=\"content-type\" "\
	"content=\"text/html; charset=utf-8\"/>\r\n"

#define LINK_ICON "<link rel=\"shortcut icon\" "\
	"href=\"/thinkos16x16.png\"/>\r\n"

#define LINK_CSS "<link rel=\"stylesheet\" href=\"/style.css\" "\
	"type=\"text/css\" media=\"screen\"/>\r\n"

#define S_MAX 256 /* HTML formatting string buffer lenght */

static const char footer_html[] = HTML_FOOTER;

/*---------------------------------------------------------------------------
  Dynamic content
  ---------------------------------------------------------------------------*/

const char index_hdr_html[] = DOCTYPE_HTML "<head>\r\n"
	"<title>ThinkOS RTSP/RTP Demo</title>\r\n"
	META_HTTP META_COPY LINK_ICON LINK_CSS
	"</head>\r\n<body>\r\n"
	"<h1>ThinkOS RTSP/RTP Demo</h1>\r\n";

const char play_hdr_html[] =
	"<p>Please fill the infomation and press <b>Play</b>.</p>\r\n"
	"<form action=\"play.cgi\" method=\"POST\"><table  width=\"400\">"
	"<col width=\"40%\"><col width=\"60%\">"
	"\r\n";

const char play_foot_html[] =
	"</table><br>\r\n"
	"<input type=\"submit\" value=\"Play\">\r\n"
	"</form>\r\n";

const char stop_hdr_html[] =
	"<form action=\"stop.cgi\" method=\"POST\">\r\n";

const char stop_foot_html[] =
	"<br>\r\n"
	"<input type=\"submit\" value=\"Stop\">\r\n"
	"</form>\r\n";

const char rtsp_iframe_html[] =
	"<iframe src=\"rtsp_msg.cgi\""
	" width=\"100%\""
	"></iframe>\r\n";

char rtsp_host[128] = "192.168.10.254";
char rtsp_media[128] = "music";
uint16_t rtsp_port = 5544;
uint16_t audio_level = 100;

int send_play_form(struct httpctl * ctl)
{
	char s[S_MAX];
	int n;

	httpd_200(ctl->tp, TEXT_HTML);
	http_send(ctl, index_hdr_html, sizeof(index_hdr_html) - 1);
	http_send(ctl, play_hdr_html, sizeof(play_hdr_html) - 1);

	n = snprintf(s, S_MAX, "<tr><td align=\"right\">RTSP server:</td><td>"
			"<input type=\"text\" name=\"host\"  size=\"32\" maxlength=\"128\" value=\"%s\"></td></tr>\r\n",
			rtsp_host);
	http_send(ctl, s, n);

	n = snprintf(s, S_MAX, "<tr><td align=\"right\">TCP Port:</td><td>"
			"<input type=\"text\" name=\"port\" size=\"5\" maxlength=\"5\" value=\"%d\"></td></tr>\r\n",
			rtsp_port);
	http_send(ctl, s, n);

	n = snprintf(s, S_MAX, "<tr><td align=\"right\">Media (MRL):</td><td>"
			"<input type=\"text\" name=\"mrl\" size=\"32\" maxlength=\"128\" value=\"%s\"></td></tr>\r\n",
			rtsp_media);
	http_send(ctl, s, n);

	n = snprintf(s, S_MAX, "<tr><td align=\"right\">Volume (0..200):</td><td>"
			"<input type=\"text\" name=\"vol\" size=\"4\" maxlength=\"3\" value=\"%d\"></td></tr>\r\n",
			audio_level);
	http_send(ctl, s, n);

	return http_send(ctl, play_foot_html, sizeof(play_foot_html) - 1);
}

int send_stop_form(struct httpctl * ctl)
{
	char * host;
	char * mrl;
	char * track;
	int port;
	char s[S_MAX];
	int n;

	host = rtsp_host_name(&rtsp);
	mrl = rtsp_media_name(&rtsp);
	track = rtsp_track_name(&rtsp);
	port = rtsp_port_get(&rtsp);

	httpd_200(ctl->tp, TEXT_HTML);
	http_send(ctl, index_hdr_html, sizeof(index_hdr_html) - 1);
	http_send(ctl, stop_hdr_html, sizeof(stop_hdr_html) - 1);

	n = snprintf(s, S_MAX, "<p><b>Playing</b> RTSP://%s:%d/%s/%s</p>\r\n",
			host, port, mrl, track);
	http_send(ctl, s, n);

	return http_send(ctl, stop_foot_html, sizeof(stop_foot_html) - 1);
}

int send_error(struct httpctl * ctl, char * msg)
{
	char s[S_MAX];
	int n;
	n = snprintf(s, S_MAX, "<p><b>Error:</b> %s!</p>\r\n", msg);
	return http_send(ctl, s, n);
}

int rtsp_msg_cgi(struct httpctl * ctl)
{
	char s[S_MAX];
	int n;

	httpd_200(ctl->tp, TEXT_HTML);

	while ((n = rtsp_recv(&rtsp, s, S_MAX)) > 0) {
		http_send(ctl, s, n);
	}

	return 0;
}

int index_cgi(struct httpctl * ctl)
{
	send_play_form(ctl);
	return http_send(ctl, footer_html, sizeof(footer_html) - 1);
}

int play_cgi(struct httpctl * ctl)
{
	strcpy(rtsp_host, http_query_lookup(ctl, "host"));
	strcpy(rtsp_media, http_query_lookup(ctl, "mrl"));
	rtsp_port = atoi(http_query_lookup(ctl, "port"));
	audio_level = atoi(http_query_lookup(ctl, "vol"));
	if (audio_level > 800)
		audio_level = 800;

	if (rtsp_connect(&rtsp, rtsp_host, rtsp_port, rtsp_media) < 0) {
		int code;

		WARN("RTSP connection failed!");
		send_play_form(ctl);
		send_error(ctl, "RTSP playback failed");
		if ((code = rtsp_response_code(&rtsp)) > 200) {
			http_send(ctl, rtsp_iframe_html, sizeof(rtsp_iframe_html) - 1);
		}
	} else {
		audio_gain_set(audio_level * Q15(1.0) / 100);
		send_stop_form(ctl);
	}

	return http_send(ctl, footer_html, sizeof(footer_html) - 1);
}

int stop_cgi(struct httpctl * ctl)
{
	if (rtsp_teardown(&rtsp) < 0) {
		WARN("RTSP teardown failed!");
	}
	send_play_form(ctl);
	return http_send(ctl, footer_html, sizeof(footer_html) - 1);
}

/*---------------------------------------------------------------------------
  static content
  ---------------------------------------------------------------------------*/

const char style_css[] = "* { border: 0; margin: 0; }\r\n"
	"body { background: #f8f8f8; color: #555; font: 0.9em Arial,Helvetica,"
		"\"bitstream vera sans\",sans-serif; margin: 10px 10px 25px 10px; }\r\n"
	"a { color: #779; text-decoration:none; }\r\n"
	"a:hover { color:#335; text-decoration:none; }\r\n"
	"p { color: #111; text-align: justify; margin: 10px 0px 20px 0px; }\r\n"
	"ul { margin: 10px 0px 20px 0px; }\r\n"
	"h1 { font-size: 1.5em; text-align:left; margin: 10px 0px 10px 0px; }\r\n"
	"h2 { font-size: 1.3em; text-align:left;  margin: 10px 0px 25px 0px; }\r\n"
	"hr { background-color:#114; color:#112; width: 100%; height: 1px; " 
		"margin: 10px 0px 5px 0px; }\r\n"
	"table { border-collapse: collapse;  margin: 0; }\r\n"
	"textarea { background:#fff; margin:1px 2px 1px; border:1px "
		"solid #aaa; padding:1px 2px 1px; }\r\n"
	"form { padding:0; margin:0; border:0; display:table;}\r\n"
	"input[type=text] { background:#fff; margin:1px 2px 1px; " 
		"border:1px solid #444; padding:3px 3px 2px; }\r\n"
	"input[type=text]:hover { background:#cdf; }\r\n"
	"input[type=button],input[type=reset],input[type=submit],button {"  
		"background:#ccc; margin:1px 4px 1px; "
		"border:1px solid #444; padding:4px 8px 3px; }\r\n"
	"input[type=button]:hover,input[type=reset]:hover,"
	"input[type=submit]:hover,button:hover {"
		" background:#458; color:#fff; text-decoration:none; }\r\n";

const uint8_t thinkos16x16_png[] = {
	0x89, 0x50, 0x4e, 0x47, 0x0d, 0x0a, 0x1a, 0x0a, 0x00, 0x00, 0x00, 0x0d,
	0x49, 0x48, 0x44, 0x52, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10,
	0x08, 0x06, 0x00, 0x00, 0x00, 0x1f, 0xf3, 0xff, 0x61, 0x00, 0x00, 0x00,
	0x04, 0x73, 0x42, 0x49, 0x54, 0x08, 0x08, 0x08, 0x08, 0x7c, 0x08, 0x64,
	0x88, 0x00, 0x00, 0x00, 0x09, 0x70, 0x48, 0x59, 0x73, 0x00, 0x00, 0x02,
	0x42, 0x00, 0x00, 0x02, 0x42, 0x01, 0xfe, 0xa1, 0x55, 0x03, 0x00, 0x00,
	0x00, 0x19, 0x74, 0x45, 0x58, 0x74, 0x53, 0x6f, 0x66, 0x74, 0x77, 0x61,
	0x72, 0x65, 0x00, 0x77, 0x77, 0x77, 0x2e, 0x69, 0x6e, 0x6b, 0x73, 0x63,
	0x61, 0x70, 0x65, 0x2e, 0x6f, 0x72, 0x67, 0x9b, 0xee, 0x3c, 0x1a, 0x00,
	0x00, 0x01, 0x73, 0x49, 0x44, 0x41, 0x54, 0x38, 0x8d, 0x95, 0x8f, 0xbf,
	0x2f, 0x43, 0x71, 0x14, 0xc5, 0x3f, 0xf7, 0xbd, 0xaa, 0xc4, 0x20, 0x2f,
	0x1d, 0x84, 0x0d, 0x61, 0xd1, 0x41, 0x78, 0x7d, 0x92, 0x9a, 0x0c, 0x06,
	0x93, 0x45, 0x22, 0xfe, 0x02, 0x61, 0xb6, 0x92, 0xf7, 0x63, 0x32, 0x98,
	0x98, 0xba, 0x88, 0x91, 0x45, 0xc4, 0x50, 0x4d, 0x8c, 0x92, 0x26, 0x0d,
	0x8d, 0x55, 0x44, 0xc2, 0x20, 0x7e, 0x0c, 0x6a, 0x7f, 0xfa, 0x5c, 0x83,
	0x96, 0xd7, 0xa6, 0x5a, 0x3d, 0xc9, 0x4d, 0xce, 0xf7, 0x7c, 0xef, 0x39,
	0xb9, 0x07, 0x55, 0x25, 0x3e, 0x64, 0xbd, 0xd4, 0x0f, 0xb7, 0xbd, 0x03,
	0x32, 0xde, 0x61, 0xab, 0xbf, 0xfa, 0x18, 0xc4, 0x20, 0x4e, 0xb0, 0x44,
	0xc8, 0x8d, 0x4c, 0xf9, 0x16, 0x4d, 0x90, 0x29, 0xdf, 0x22, 0xe4, 0x46,
	0x9c, 0x60, 0x29, 0xae, 0x37, 0x04, 0x10, 0xf6, 0x15, 0x80, 0x2a, 0xa6,
	0xac, 0xd7, 0x94, 0x5d, 0x22, 0x76, 0x00, 0x6a, 0x5a, 0xb5, 0xb6, 0xf3,
	0x0b, 0x55, 0x05, 0xc7, 0x9b, 0xc7, 0xce, 0xf5, 0x7c, 0xf3, 0x20, 0x5d,
	0xe7, 0x0d, 0xd5, 0xec, 0x5c, 0x0f, 0x4e, 0x90, 0xfe, 0xe5, 0xde, 0xbc,
	0xaa, 0x22, 0x64, 0xbd, 0x14, 0x21, 0xf7, 0xc0, 0x33, 0x11, 0x0b, 0x7a,
	0xed, 0x3e, 0x34, 0x9f, 0xdf, 0x54, 0x65, 0x18, 0x93, 0x02, 0x30, 0x44,
	0x92, 0x11, 0x43, 0x8b, 0x6e, 0x85, 0x04, 0x69, 0x94, 0x3c, 0x16, 0x8f,
	0xed, 0xcc, 0x00, 0x58, 0x3c, 0xa2, 0xe4, 0x49, 0x90, 0xd6, 0xa2, 0x5b,
	0x11, 0x55, 0xed, 0xe8, 0x69, 0x7b, 0x11, 0xb6, 0xb7, 0x0d, 0x80, 0xc9,
	0x3e, 0x1f, 0xc9, 0x77, 0x8c, 0x70, 0xa3, 0xe5, 0xa6, 0xc9, 0xbe, 0x96,
	0xdc, 0x5b, 0x00, 0x99, 0xf1, 0x47, 0xf9, 0x64, 0x15, 0x20, 0x01, 0xcc,
	0x01, 0x50, 0xe5, 0x04, 0x23, 0x8a, 0x80, 0x95, 0x98, 0x6d, 0x00, 0x88,
	0x80, 0x37, 0xd4, 0x38, 0x03, 0x6e, 0x01, 0xf8, 0xc4, 0xaa, 0xfb, 0xda,
	0x56, 0x90, 0x8c, 0x7f, 0x82, 0xf2, 0xa2, 0x65, 0x77, 0xed, 0xaf, 0x1d,
	0x03, 0x40, 0xc4, 0x37, 0xc4, 0xf1, 0x17, 0x3b, 0xf5, 0x6d, 0x19, 0x20,
	0xb3, 0x7e, 0x0a, 0x9b, 0x2b, 0x94, 0x23, 0xb1, 0xfd, 0xb1, 0xae, 0x03,
	0xb4, 0xe8, 0x56, 0x10, 0x4e, 0x31, 0xcd, 0x09, 0x2d, 0xbb, 0x77, 0x32,
	0xbe, 0xd7, 0xdb, 0x55, 0x00, 0x80, 0x5e, 0xba, 0x9e, 0x96, 0x36, 0xef,
	0x45, 0x10, 0xfa, 0x2b, 0x17, 0x92, 0x09, 0xd6, 0x3b, 0x19, 0x1b, 0x02,
	0x7e, 0x30, 0x1d, 0x2c, 0x23, 0x4c, 0xa2, 0x7a, 0xfe, 0xdf, 0x80, 0x44,
	0xc3, 0x4b, 0x06, 0x8f, 0xd1, 0xd7, 0x27, 0x2d, 0x6f, 0xdd, 0xfd, 0x37,
	0xe0, 0x0b, 0xca, 0x0a, 0xaf, 0x48, 0x18, 0x12, 0x78, 0x63, 0x00, 0x00,
	0x00, 0x00, 0x49, 0x45, 0x4e, 0x44, 0xae, 0x42, 0x60, 0x82,
};

const uint8_t thinkos47x20_png[] = {
	0x89, 0x50, 0x4e, 0x47, 0x0d, 0x0a, 0x1a, 0x0a, 0x00, 0x00, 0x00, 0x0d,
	0x49, 0x48, 0x44, 0x52, 0x00, 0x00, 0x00, 0x2f, 0x00, 0x00, 0x00, 0x14,
	0x08, 0x06, 0x00, 0x00, 0x00, 0x1d, 0x9a, 0x64, 0xc2, 0x00, 0x00, 0x04,
	0x8a, 0x49, 0x44, 0x41, 0x54, 0x48, 0xc7, 0xbd, 0xd6, 0x59, 0x88, 0x56,
	0x65, 0x18, 0x07, 0xf0, 0xdf, 0x37, 0xf3, 0x8d, 0x8e, 0x7b, 0x8b, 0x46,
	0xb4, 0x53, 0x44, 0xb4, 0x27, 0x47, 0xa2, 0x28, 0x2b, 0x0b, 0x83, 0x0a,
	0xac, 0x84, 0x12, 0x5a, 0x10, 0xda, 0x10, 0x21, 0xba, 0x28, 0x73, 0x28,
	0xa2, 0x97, 0xea, 0xa2, 0xcd, 0x0c, 0xea, 0x2a, 0x35, 0x25, 0x42, 0xeb,
	0x22, 0x12, 0xbd, 0xb0, 0x50, 0x42, 0x5b, 0xc5, 0x3a, 0x85, 0x65, 0x05,
	0x59, 0xb4, 0x40, 0x5a, 0xb6, 0x39, 0xa6, 0x39, 0xea, 0xcc, 0x9c, 0x2e,
	0xe6, 0xf9, 0xbe, 0x79, 0xfb, 0x5c, 0xb0, 0x0b, 0x3d, 0x70, 0x38, 0xef,
	0x79, 0xd7, 0xe7, 0xf9, 0x3f, 0xff, 0xe7, 0xff, 0xbc, 0x35, 0x50, 0x24,
	0xca, 0xa4, 0xd9, 0xa6, 0x86, 0x4a, 0x99, 0x28, 0xd2, 0x48, 0xcc, 0xc3,
	0xc5, 0x38, 0x5f, 0x99, 0xba, 0x15, 0xa9, 0x0d, 0x15, 0x28, 0x53, 0x15,
	0x6b, 0x06, 0xf7, 0x38, 0x4c, 0x4f, 0x5b, 0xf3, 0xe0, 0xc1, 0xe7, 0x0a,
	0xac, 0xc5, 0xe9, 0xcd, 0x39, 0x03, 0xce, 0x34, 0x5e, 0x38, 0x19, 0xaf,
	0xe2, 0xc1, 0x6c, 0xce, 0xe0, 0x53, 0xa4, 0xc3, 0x64, 0x7c, 0x99, 0x5a,
	0x11, 0xdb, 0x8d, 0x0b, 0xf1, 0x54, 0x66, 0xd8, 0x56, 0xfc, 0x8e, 0xfe,
	0xe8, 0xbb, 0x12, 0xb7, 0x60, 0x78, 0xfc, 0xb7, 0x47, 0x94, 0x0e, 0x6b,
	0x04, 0xea, 0xff, 0xa1, 0x4c, 0x1c, 0x8d, 0x97, 0x71, 0x91, 0x22, 0x1d,
	0x81, 0x6e, 0x65, 0x9a, 0x91, 0xa1, 0x3a, 0x02, 0x13, 0xf1, 0x29, 0x5e,
	0x88, 0xde, 0xde, 0xa6, 0xd1, 0x7b, 0xef, 0x77, 0xc8, 0x9e, 0x5a, 0xa0,
	0x75, 0x09, 0x7a, 0xb0, 0x3e, 0xb8, 0xdc, 0x89, 0x7e, 0x65, 0xda, 0xa9,
	0x48, 0x39, 0x65, 0xfa, 0x83, 0xe3, 0x43, 0x30, 0x4a, 0x99, 0xfe, 0x08,
	0x87, 0xce, 0xc7, 0x58, 0xac, 0x51, 0xa6, 0x5e, 0x45, 0xaa, 0x29, 0x53,
	0x75, 0xe8, 0x69, 0x33, 0x60, 0xd4, 0xf3, 0xf8, 0x04, 0x73, 0x31, 0x04,
	0xbb, 0xb0, 0x3b, 0x50, 0xac, 0x82, 0x2e, 0x7d, 0x59, 0x72, 0xf6, 0xe2,
	0x0f, 0x45, 0x6a, 0x57, 0xa4, 0x3b, 0x23, 0x5a, 0x2f, 0x61, 0xfc, 0x3e,
	0x73, 0xe0, 0x10, 0x23, 0x7f, 0x0e, 0x9e, 0xc3, 0x49, 0x38, 0xaf, 0x69,
	0x6c, 0x43, 0x51, 0xf6, 0xb5, 0x6e, 0x30, 0x02, 0x73, 0x71, 0x03, 0xee,
	0x52, 0xa6, 0x15, 0x11, 0x29, 0x4d, 0xb5, 0xca, 0xd5, 0x6c, 0x7f, 0x89,
	0xdc, 0x9a, 0x2f, 0xf9, 0xbc, 0xff, 0xaa, 0xe0, 0xde, 0xfd, 0x19, 0x9f,
	0x8f, 0xf9, 0xdf, 0xee, 0x17, 0x69, 0x98, 0x22, 0x0d, 0xdb, 0xcf, 0xd8,
	0xc1, 0x29, 0x4f, 0x3e, 0xaf, 0x75, 0x7e, 0x63, 0x6c, 0x1f, 0xfd, 0x35,
	0x45, 0xea, 0x8c, 0x30, 0xb7, 0x61, 0x47, 0x0c, 0x75, 0xb6, 0xa0, 0x5e,
	0xcb, 0xda, 0x7d, 0x11, 0x99, 0x0e, 0xec, 0x89, 0xff, 0xa1, 0xa8, 0x67,
	0xff, 0xf5, 0xa0, 0xd9, 0x9e, 0x03, 0x20, 0xdf, 0x19, 0xfb, 0xec, 0xde,
	0x2b, 0x42, 0x03, 0xed, 0xa1, 0xca, 0xb4, 0x6b, 0xa0, 0x7d, 0x37, 0xe5,
	0x3c, 0x51, 0x5f, 0xda, 0x1b, 0xfb, 0xd6, 0x23, 0xec, 0x35, 0x6c, 0x55,
	0xa6, 0x2e, 0x45, 0x1a, 0x83, 0x17, 0xd1, 0x1d, 0xe3, 0xc2, 0xa8, 0x7e,
	0x8c, 0xc1, 0x06, 0x7c, 0x8e, 0x1b, 0xb1, 0x50, 0x99, 0xd6, 0x29, 0xd2,
	0xf5, 0xf1, 0xff, 0x23, 0x3e, 0xc0, 0xb9, 0xf8, 0x16, 0xaf, 0x67, 0xf4,
	0xac, 0xb2, 0xc4, 0xaf, 0x30, 0x1b, 0x9b, 0xf1, 0x0a, 0x7a, 0x9a, 0x74,
	0x2b, 0x52, 0x07, 0xa6, 0x84, 0xda, 0x7d, 0x82, 0xa5, 0xca, 0xd4, 0xa3,
	0x48, 0x27, 0xc6, 0x19, 0xc7, 0x2a, 0xd2, 0x67, 0x58, 0x59, 0xc7, 0x4d,
	0x81, 0xfa, 0x66, 0x74, 0x85, 0x76, 0xdf, 0x16, 0xba, 0xde, 0x11, 0x63,
	0xa3, 0x9a, 0x3c, 0x66, 0x45, 0xf4, 0xcf, 0xc0, 0xc7, 0x58, 0x87, 0xb3,
	0x30, 0x2d, 0xd4, 0xea, 0x6f, 0xdc, 0x83, 0x55, 0x4d, 0xe3, 0x07, 0x95,
	0xa7, 0x42, 0x15, 0x08, 0xce, 0xc0, 0x17, 0x78, 0x0d, 0x3d, 0xcd, 0x39,
	0x45, 0x9a, 0x8d, 0xc7, 0x02, 0xb0, 0x0e, 0x3c, 0xa1, 0x48, 0x4f, 0x63,
	0x35, 0x4e, 0x0d, 0x76, 0x8c, 0xc0, 0x82, 0x7a, 0xa0, 0x54, 0x6b, 0x6a,
	0x35, 0xbf, 0xe1, 0x82, 0x08, 0x7f, 0x2f, 0x8e, 0xc4, 0x93, 0x38, 0x21,
	0x0c, 0xfc, 0x1e, 0x93, 0x9b, 0x11, 0x19, 0xa0, 0xc2, 0xa2, 0x50, 0x9b,
	0x3e, 0x9c, 0x12, 0x45, 0xee, 0xf3, 0x66, 0xf8, 0x07, 0x68, 0xf5, 0x4f,
	0xec, 0xd5, 0x83, 0xed, 0xf1, 0xee, 0x8c, 0x35, 0x14, 0x69, 0x6c, 0xb4,
	0x67, 0x45, 0xd4, 0xba, 0xf0, 0x68, 0x54, 0xf1, 0x9f, 0xc2, 0xf0, 0x47,
	0xb0, 0x14, 0x93, 0x30, 0xa2, 0xae, 0x4c, 0x9b, 0xb3, 0x24, 0x68, 0xf0,
	0x6c, 0x7d, 0xd6, 0x37, 0x2a, 0xbc, 0xed, 0xc3, 0x7a, 0x65, 0xda, 0xa3,
	0x08, 0x2e, 0x73, 0x59, 0x54, 0xda, 0xee, 0x38, 0xf4, 0xaa, 0x70, 0xf0,
	0x67, 0x7c, 0x17, 0x73, 0xae, 0xc7, 0xe5, 0xd8, 0x84, 0xab, 0xf1, 0x0d,
	0x1e, 0x8a, 0x28, 0x0c, 0x09, 0x00, 0xee, 0x88, 0x39, 0x5f, 0x45, 0x2e,
	0xcc, 0x57, 0xa6, 0x37, 0x14, 0xe9, 0xf8, 0xa0, 0xf5, 0xcd, 0x01, 0xe4,
	0x07, 0xca, 0xb4, 0x21, 0xa8, 0xab, 0x1e, 0x21, 0x1c, 0x1b, 0x68, 0x5d,
	0x6a, 0x42, 0xea, 0x52, 0xe9, 0x88, 0x82, 0xd4, 0x97, 0x51, 0xa7, 0xd6,
	0x92, 0xa4, 0x8d, 0x6b, 0x82, 0x40, 0xe5, 0xfb, 0x30, 0x78, 0x12, 0x86,
	0xc5, 0x9a, 0xe5, 0x98, 0x80, 0x99, 0xe1, 0x50, 0x4f, 0x38, 0xbc, 0x32,
	0xd6, 0xed, 0xc4, 0x75, 0x98, 0x8f, 0x65, 0xf8, 0x0b, 0xed, 0xf8, 0x51,
	0x91, 0xea, 0x91, 0x43, 0x6d, 0x41, 0xc5, 0x3a, 0x16, 0x29, 0x52, 0x17,
	0x3e, 0x52, 0xa6, 0x1f, 0x1a, 0xb7, 0xc3, 0xc7, 0xe3, 0xa0, 0xa9, 0x2a,
	0x47, 0xa3, 0x37, 0x0c, 0x17, 0x89, 0x5a, 0x65, 0x4a, 0x23, 0xbb, 0xe3,
	0xcc, 0x09, 0xda, 0x6d, 0xc7, 0x29, 0xca, 0x34, 0x3f, 0xf8, 0xbf, 0x29,
	0xa3, 0xe1, 0xb6, 0xf8, 0x4e, 0x8b, 0x44, 0xec, 0x89, 0xba, 0x32, 0x3c,
	0x40, 0x5b, 0x88, 0x0f, 0xa3, 0x56, 0xd4, 0x9a, 0xaa, 0x57, 0xa6, 0xde,
	0x4c, 0xfd, 0xd6, 0x46, 0x62, 0x1f, 0x85, 0xc5, 0x58, 0xa2, 0x48, 0x67,
	0xb5, 0x65, 0x07, 0x2c, 0xc0, 0xe4, 0xac, 0xe4, 0x1f, 0xa8, 0x4a, 0x76,
	0x64, 0xf9, 0x31, 0x3c, 0xbe, 0x9d, 0xd1, 0x37, 0x2e, 0xda, 0x8d, 0xf5,
	0x43, 0x33, 0x87, 0x77, 0x84, 0x53, 0x43, 0xa3, 0x3d, 0x31, 0x14, 0x6c,
	0x79, 0x48, 0x64, 0x7f, 0xf3, 0xa2, 0x37, 0xa0, 0x3e, 0xed, 0xf1, 0xdf,
	0xa3, 0x4c, 0xd3, 0x43, 0x08, 0xde, 0xc6, 0x45, 0x8d, 0x84, 0xad, 0x94,
	0x69, 0x56, 0x8b, 0x71, 0x53, 0x71, 0x1a, 0x9e, 0x3e, 0x88, 0x52, 0xdf,
	0x17, 0x87, 0x54, 0x19, 0x15, 0xfa, 0x33, 0x43, 0xaa, 0x96, 0x68, 0xd5,
	0x32, 0xbe, 0xff, 0x82, 0x1f, 0xf0, 0xb0, 0x22, 0x2d, 0xc6, 0xaf, 0x31,
	0x36, 0x2e, 0x2a, 0xf8, 0xd8, 0x58, 0xf3, 0x67, 0xa8, 0xd6, 0x92, 0x40,
	0xfd, 0x23, 0x8c, 0xaf, 0x67, 0x28, 0xb7, 0x47, 0x32, 0x9e, 0x11, 0x21,
	0xda, 0xa6, 0x48, 0xcf, 0x65, 0x87, 0xf5, 0x67, 0x06, 0x57, 0x2d, 0xdf,
	0xbe, 0x6c, 0x6c, 0x74, 0x66, 0x9c, 0x0c, 0xbd, 0x2a, 0x73, 0xaa, 0x37,
	0xa2, 0xb7, 0x26, 0xae, 0x25, 0xab, 0x71, 0x7f, 0xd0, 0xb0, 0x17, 0xd7,
	0x2a, 0xd2, 0xdb, 0xb8, 0x26, 0x8b, 0xc4, 0xa5, 0xf8, 0x1a, 0x23, 0x23,
	0x37, 0x86, 0xb4, 0x65, 0xf7, 0x90, 0x86, 0x82, 0x9c, 0x19, 0x77, 0xfa,
	0x7b, 0x83, 0x77, 0x6d, 0xa1, 0xab, 0xa3, 0xb3, 0x4a, 0xdb, 0x91, 0x7d,
	0x1b, 0xe3, 0xe3, 0x14, 0x69, 0x26, 0x9e, 0x0d, 0xea, 0x4c, 0x51, 0xa4,
	0x87, 0x71, 0x76, 0xcb, 0xdc, 0x51, 0x91, 0xd0, 0x23, 0x70, 0x9c, 0x32,
	0xad, 0xc3, 0x9b, 0xb8, 0x2f, 0xc6, 0xde, 0x09, 0xfe, 0x2f, 0xc4, 0xad,
	0x78, 0x3f, 0x0c, 0x7e, 0x2f, 0x1c, 0x9d, 0x13, 0x4e, 0xbd, 0x55, 0x8f,
	0xb2, 0x9d, 0x5f, 0x05, 0x56, 0x61, 0xba, 0x32, 0x2d, 0xcb, 0x68, 0xf0,
	0x29, 0xb6, 0x64, 0xe8, 0x6f, 0xc1, 0x97, 0x11, 0xe6, 0x3d, 0x78, 0x37,
	0x8a, 0xda, 0x19, 0x38, 0x31, 0x12, 0xf0, 0xc8, 0x50, 0x9a, 0xcd, 0x61,
	0x50, 0x77, 0x24, 0xeb, 0x6a, 0x6c, 0x8c, 0x35, 0x1b, 0x15, 0x69, 0x38,
	0x9e, 0x89, 0xfa, 0x30, 0x09, 0x0f, 0x44, 0xd4, 0xae, 0x8c, 0x7d, 0x66,
	0x86, 0xe3, 0xab, 0x70, 0x7b, 0x00, 0xb8, 0x1c, 0x8f, 0xfc, 0x0b, 0x7e,
	0xa7, 0xb5, 0xdd, 0x5e, 0xab, 0x7b, 0x82, 0x00, 0x00, 0x00, 0x00, 0x49,
	0x45, 0x4e, 0x44, 0xae, 0x42, 0x60, 0x82,
};


/*---------------------------------------------------------------------------
  root directory content
  ---------------------------------------------------------------------------*/

struct httpdobj www_root[] = {
	{ .oid = "style.css", .typ = OBJ_STATIC_CSS, .lvl = 255, 
		.len = sizeof(style_css) - 1, .ptr = style_css },
	{ .oid = "thinkos16x16.png", .typ = OBJ_STATIC_PNG, .lvl = 255,
		.len = sizeof(thinkos16x16_png) - 1, .ptr = thinkos16x16_png },
	{ .oid = "thinkos47x20.png", .typ = OBJ_STATIC_PNG, .lvl = 255,
		.len = sizeof(thinkos47x20_png) - 1, .ptr = thinkos47x20_png},
	{ .oid = "index.html", .typ = OBJ_CODE_CGI, .lvl = 255,
		.len = sizeof(index_cgi) - 1, .ptr = index_cgi },
	{ .oid = "play.cgi", .typ = OBJ_CODE_CGI, .lvl = 100,
		.len = 0, .ptr = play_cgi },
	{ .oid = "stop.cgi", .typ = OBJ_CODE_CGI, .lvl = 100,
		.len = 0, .ptr = stop_cgi },
	{ .oid = "rtsp_msg.cgi", .typ = OBJ_CODE_CGI, .lvl = 100,
		.len = 0, .ptr = rtsp_msg_cgi },
	{ .oid = NULL, .typ = 0, .lvl = 0, .len = 0, .ptr = NULL }
};

struct httpddir httpd_dir[] = {
	{ .path = "/", .objlst = www_root },
	{ .path = NULL, .objlst = NULL }
};

int http_server_task(struct httpd * httpd)
{
	struct httpctl httpctl;
	struct httpctl * ctl = &httpctl;
	const struct httpdobj * obj;

	INF("Webserver started (thread %d).", thinkos_thread_self());

	for (;;) {
		if (http_accept(httpd, ctl) < 0) {
			ERR("tcp_accept() failed!\n");
			thinkos_sleep(1000);
			continue;
		}

		if ((obj = http_obj_lookup(ctl)) != NULL) {
			switch (ctl->method) {
			case HTTP_GET:
				DBG("HTTP GET \"%s\"", obj->oid);
				http_get(ctl, obj);
				break;
			case HTTP_POST:
				DBG("HTTP POST \"%s\"", obj->oid);
				http_post(ctl, obj);
				break;
			}
		}

		http_close(ctl);
	}

	return 0;
}

uint32_t httpd_stack[512];

const struct thinkos_thread_inf httpd_inf = {
	.stack_ptr = httpd_stack,
	.stack_size = sizeof(httpd_stack),
	.priority = 32,
	.thread_id = 12,
	.paused = 0,
	.tag = "HTTPD"
};

int webserver_start(void)
{
	struct httpd * httpd;

	httpd = httpd_alloc();

	httpd_init(httpd, 80, 4, httpd_dir, NULL);

	return thinkos_thread_create_inf((void *)http_server_task,
			(void *)httpd, &httpd_inf);
}
